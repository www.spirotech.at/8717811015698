Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC300F_INT-EN.ifc
Time: 2025-08-05T18:33:36+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (4)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2152121_3
Port_2152121_4
Port_2152121_7
Port_2152121_8

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN:XC300F, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN:XC300F:2152121
In: F00
Type - Material: Color RGB 198-000-000, Color RGB 128-128-128, Color RGB 168-128-048, Color RAL 1003
Type - Other - Category: Pipe Accessories; Base Flange: 23.5 mm; Base Flange Radius: 161.95 mm; Bottom Geomtry Height: 95 mm; Brackets Height: 20 mm; Chamfer Radius: 122 mm; Cone Flange: 34 mm; Cone Flange Radius Bottom: 181 mm; Cone Flange Radius Top: 161.95 mm; Connection Diameter: 301 mm; Distance Between Brackets: 408 mm; DN: 301 mm; Drain Height: 245 mm; Drain Offset: 174.5 mm; Drain Radius: 30.15 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN; Flange Body: 24 mm; Flange Body Radius: 230 mm; Flange Gasket: 4 mm; Flange Gasket Radius: 189 mm; Front Bracket Height: 280 mm; Front Bracket Offset: 2000 mm; Front Bracket Offset 2: 305 mm; h: 996 mm; H1: 465 mm; h2: 1097 mm; h3: 245 mm; Inner Diameter Ring: 10 mm; OD: 323.9 mm; Outer Diameter Bracket: 64 mm; Type Value: 17; Upper Geometry Radius: 12 mm; Upper Side Height: 995 mm; Width: 758 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 610 mm; H: 3388 mm; L: 834 mm; LF: 1005 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Low-loss Header with Deaerator & dirt separator - Steel - Flange DN300; Article Type: XC300F; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Low-loss Header with Deaerator & dirt separator - Steel - Flange DN300; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811015698; Manufacturer: Spirotech; Manufacturer Art. No.: XC300F; Manufacturer URL: https://www.spirotech.com/8717811015698; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: XC300F; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: XC300F; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.1125 m3/s; Pressure Stage: 16; Volume: 0.859 m3; Weight: 656 kg
Type - Mechanical - Flow - Pressure Drop: 7700 Pa
Type - Visibility - Flange: yes; Front Bracket: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: XC300F; sets with these values: 2
Other - Bottom Clearance Safe: 100 mm; Connection Length: 1005 mm; Connectors Length: 1005 mm; Connectors Length Safe: 1133 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN: XC300F; Length: 1005 mm; Top Clearance Safe: 50 mm; Type: XC300F; Type Id: 2152072
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 6.99928 m2; Maximum Size: 301 mm; Minimum Size: 301 mm; Volume: 1.02874 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Flow In 2: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 100 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
